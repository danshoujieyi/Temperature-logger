# Keil uVision project UART.uvprojx, settings and files
target UART_Debug (ARM-ADS)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: UART +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c define: __DEBUG_RAM
  c include: .;..\Common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group StartFile
    ../Common/src/: system_LPC11xx.c core_cm0.c startup_LPC11xx.s
  group Source
    ./Source/: main.c
    ./: AD_UART.c AD_UART.h Music.c Music.h OLED.c OLED.h OLED_Font.h Delay.c Delay.h I2C.c I2C.h DS1307.c DS1307.h LM75BD.c LM75BD.h UART.c UART.h DS18B20.c DS18B20.h XT25F02.c XT25F02.h SSPI1.c SSPI1.h LED.c LED.h
target UART_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: as above
  output: UART +hex
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3
  c define: __DEBUG_FLASH
  c include: .;..\Common\inc;..\u8g2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
software components: CMSIS:CORE 6.1.0
